## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
	bool "ldd"
	help
	  Installs the following modules from ldd3 repository: misc-modules, scull
```
